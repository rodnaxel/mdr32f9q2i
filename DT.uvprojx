# Keil uVision project DT.uvprojx, settings and files
target MDR32F9Q2I (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DT +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c include: .\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./source/: button.c clk.c led.c main.c uart.c
  group config
    ./config/: MDR32F9Qx_board.h MDR32F9Qx_config.h MDR32F9Qx_lib.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:UART 2.0.3
